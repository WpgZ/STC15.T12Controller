# Keil uVision project T12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F204EA STC
  cpu: IRAM(0-0xFF) IROM(0-0xFF8) CLOCK(35000000)
  output: T12 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: Display.c main.c Delay.c Pid.c RotaryEncoder.c beep.c Config.c eeprom.c ADC.c
